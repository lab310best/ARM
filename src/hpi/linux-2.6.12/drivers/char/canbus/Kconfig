## src/hpi/linux-2.6.12/drivers/char/canbus/Kconfig
```kconfig
#
# MCP2510 configuration
#
menu "Can--Bus"

config MCP
	tristate "MCP2510 DRIVER NEW!!!"
	---help---
	can driver!

endmenu
```
